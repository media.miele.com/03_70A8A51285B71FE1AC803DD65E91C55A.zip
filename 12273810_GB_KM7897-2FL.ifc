Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: bb340a93-2330-434a-9bad-acd52b6afb95, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T22:09:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12273810_GB_KM7897-2FL:26789774_GB_12273810_KM7897-2FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, <Unnamed>, z_Miele_Design_Glass Black, Default
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 936 mm; Height: 51 mm; Depth: 520 mm
Pset_BuildingElementProxyCommon - Reference: 26789774_GB_12273810_KM7897-2FL; sets with these values: 2
